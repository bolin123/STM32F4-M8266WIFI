# Keil uVision project STM32F4-M8266WIFI.uvprojx, settings and files
target STM32F4_M8266WIFI (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F4_M8266WIFI +hex
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\CORE;..\FWLIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE;..\M8266WIFI;..\USER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_spi.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: System.c SysTimer.c Wifi.c MSocket.c
  group HARDWARE
    ../HARDWARE/: HalGPIO.c HalTimer.c HalUart.c Hal.c
  group M8266WIFI
    ../M8266WIFI/: M8266HostIf_STM32xx.c M8266WIFI_ops.c M8266WIFIDrv_STM32F4xx.lib
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c Demo.c
  group README
    ../: readme.txt
